# Repository WB2CBA/QO100-PORTABLE-TRANSCEIVER-PROJECT

File README.md:

# QO100-PORTABLE-TRANSCEIVER-PROJECT

## KiCad design QO100 PA/QO100_PA.kicad_pcb

Parts:
C1: 100uF/50V; CP_Elec_6.3x7.7
C2: 1000uF/16V; CP_Elec_10x10.5
D1, D3: SS34; D_SMA
D2: PWR; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1: PATCH01; PinHeader_1x20_P2.54mm_Vertical
J2: PATCH02; PinHeader_1x20_P2.54mm_Vertical
J3: PJ-102A; Barrel_Jack_5.5mmODx2.1mmID_PJ-102A; MPN PJ-102A; Digi-Key_PN CP-102A-ND
J4: EDUP PWR; PinHeader_1x02_P2.54mm_Vertical
L1: 100uH; L_Bourns-SRN8040_8x8.15mm-MOD
R1: 1k; R_0805_2012Metric
SW1: POWER SW; EG1206
U1: SKY65135Module; SKY65135_MODULE
U2: LM2576S-5; TO-263-5_TabPin3

Connections:
+5V: C2.1, J1.9, L1.2, U1.2, U1.3, U2.4 (FB)
+12V: C1.1, J1.8, J4.1, R1.1, SW1.2 (B), U2.1 (VIN)
GNDPWR: C1.2, C2.2, D2.1 (K), D3.2 (A), H1.1, H2.1, H3.1, H4.1, J1.18, J1.19, J1.20, J2.18, J2.19, J2.20, J3.2, J3.3, J4.2, U1.4, U1.5, U1.6, U2.3 (GND), U2.5 (~ON~/OFF)
unnamed: D1.1 (K), SW1.3 (C)
unnamed: D1.2 (A), J3.1
unnamed: D2.2 (A), R1.2
unnamed: D3.1 (K), L1.1, U2.2 (OUT)

Notes on the sheet:
PSU Unit

Board: 2 copper layers, 111.0 x 97.0 mm, 18 parts (1 on the bottom side), 7 nets.

## KiCad design QO100 TX MODULE/QO100 TX MODULE UNIT/QO100_TX.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C8, C9, C13, C14, C16, C18, C20, C21, C22, C27, C32: 100nF; C_0805_2012Metric
C7: 4.7uF; C_0805_2012Metric
C10, C11: 4.7nF; C_0805_2012Metric
C12, C23, C25, C34, C49: 10uF/16V; CP_Elec_4x5.4
C15, C50: 100uF/16V; CP_Elec_6.3x7.7
C17, C24, C26, C30, C40, C44, C48: 10nF; C_0805_2012Metric
C19, C28, C35, C36, C37: 100pF; C_0805_2012Metric
C29, C39, C41, C42, C47: 1nF; C_0805_2012Metric
C31: 10uF; C_0805_2012Metric
C33: 10pF; C_0805_2012Metric
C38: 470pF; C_0805_2012Metric
C43: 1.5nF; C_0805_2012Metric
C45, C46: 4.3pF; C_0805_2012Metric
D1: SS34; D_SMA
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1: PATCH01; PinHeader_1x20_P2.54mm_Vertical
J2: PATCH02; PinHeader_1x20_P2.54mm_Vertical
J3: MIC/PTT; Jack_3.5mm_PJ-320B-SMT_Horizontal_CORR
J4: ADF4360+AD8346 SHIELD; Laird_Technologies_BMI-S-210-F_44.00x30.50mm
J5: SMA RF OUT; SMA_Samtec_SMA-J-P-X-ST-EM1_EdgeMount
J7: SP5189 SHIELD; Wuerth_36103205_20x20mm
L1, L2, L3, L4, L10: 100uH; L_1210_3225Metric
L5: 47nH; L_0805_2012Metric
L6, L7: 100nH; L_0603_1608Metric
L8, L9: 8.7nH; L_0603_1608Metric
R1: 51k; R_0805_2012Metric
R2, R3, R4, R5, R6, R8: 10k; R_0805_2012Metric
R7: 1ok; R_0805_2012Metric
R9, R12: 5k6; R_0805_2012Metric
R10, R13: 1k8; R_0805_2012Metric
R11: 50R; R_0805_2012Metric
R14: 4k7; R_0805_2012Metric
R15: 0R; R_0805_2012Metric
R16, R17: 2k; R_0805_2012Metric
SW1: RESET; SW_Push_1P1T_NO_6x6mm_H9.5mm
U1: RP2040_PICO; RPI2040_PICO_SMD
U2, U3: LM4562; SOIC-8_3.9x4.9mm_P1.27mm
U4: AD8346ARUZ-REEL7; AD8346SEDA
U5: LM1117-5.0; SOT-223-3_TabPin2
U6: LM1117-3.3; SOT-223-3_TabPin2
U7: SPF5189Z; SOT-89-3
U8: ADF4360-0BCP; ADF4360SEDA
Y1: 10Mhz; Crystal_SMD_SeikoEpson_FA238V-4Pin_3.2x2.5mm

Connections:
+3V3: C12.1, C13.1, C20.1, C27.1, C31.1, C50.1, J1.10, L2.1, L6.2, L7.2, L10.2, U6.2 (VO), U8.23 (CE), Y1.3
+5V: C5.1, C21.1, C23.1, C36.1, C37.1, J1.9, L1.1, L3.2, L4.2, R15.1, U5.2 (VO), U6.3 (VI)
+12V: D1.2 (A), J1.8
ADF_LON: L9.1, U4.5 (LOIN)
ADF_LOP: L8.1, U4.6 (LOIP)
ADF_MUX: U1.6 (GP4), U8.20 (MUXOUT)
ADF_TX_CLK: U1.14 (GP10), U8.17 (CLK)
ADF_TX_DATA: U1.15 (GP11), U8.18 (DATA)
ADF_TX_LE: U1.17 (GP13), U8.19 (LE)
GNDPWR: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C25.2, C27.2, C28.2, C29.2, C30.2, C32.2, C34.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C44.2, C47.2, C48.2, C49.2, C50.2, H1.1, H2.1, H3.1, H4.1, J1.18, J1.19, J1.20, J2.18, J2.19, J2.20, J3.S, J4.1, J5.2 (Ext), J7.1, R2.2, R10.2, R11.2, R13.2, R14.2, R17.2, SW1.2, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (GND), U1.38 (GND), U2.4 (V-), U3.4 (V-), U4.3 (COM1), U4.4 (COM1), U4.9 (COM2), U4.10 (COM3), U4.13 (COM4), U4.14 (COM4), U5.1 (GND), U6.1 (GND)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
IQ_REF1: C22.1, C25.1, R9.2, R10.1, U2.5 (+)
IQ_REF2: C32.1, C34.1, R12.2, R13.1, U3.5 (+)
I_OUT+: R5.1, U2.1, U2.2 (-), U4.1 (IBBP)
I_OUT-: R7.2, U2.7, U4.2 (IBBN)
KEY1: C9.1, J1.11, U1.10 (GP7)
KEY2: C8.1, J1.12, U1.11 (GP8)
KEY3: C6.1, J1.13, U1.12 (GP9)
LCD_SCL: J2.16, U1.25 (GP19)
LCD_SDA: J2.17, U1.24 (GP18)
MCU_SCL: J2.11, U1.22 (GP17)
MCU_SDA: J2.12, U1.21 (GP16)
MIC: C7.1, J3.T
unnamed: C7.2, R1.2, R2.1, U1.34 (GP28)
unnamed: C10.1, R3.2, U2.3 (+)
unnamed: C11.1, R4.2, U3.3 (+)
unnamed: C14.1, C16.1, L3.1, U2.8 (V+), U3.8 (V+)
unnamed: C15.1, C18.1, D1.1 (K), U5.3 (VI)
unnamed: C17.1, C19.1, C28.1, C30.1, L2.2, U4.7 (VPS1), U4.8 (ENBL), U4.12 (VPS2)
unnamed: C24.1, Y1.4
unnamed: C24.2, C26.1, R11.1
unnamed: C26.2, U8.16 (REFIN)
unnamed: C29.1, U8.12 (CC)
unnamed: C31.2, U8.14 (CN)
unnamed: C33.1, U7.1
unnamed: C33.2, U4.11 (VOUT)
unnamed: C35.1, J5.1 (In)
unnamed: C35.2, L5.2, U7.3
unnamed: C38.1, R16.2, U8.7 (VTUNE)
unnamed: C39.1, C40.1, C42.1, C44.1, C47.1, C48.1, C49.1, L10.1, U8.2 (AVDD), U8.6 (VVCO), U8.21 (DVDD)
unnamed: C41.1, C43.1, R16.1, U8.24 (CP)
unnamed: C43.2, R17.1
unnamed: C45.1, L7.1, U8.4 (RFOUTA)
unnamed: C45.2, L8.2
unnamed: C46.1, L6.1, U8.5 (RFOUTB)
unnamed: C46.2, L9.2
unnamed: L1.2, U1.40 (VBUS)
unnamed: L4.1, R9.1, R12.1
unnamed: L5.1, R15.2
unnamed: R1.1, U1.35 (A_REF)
unnamed: R5.2, R7.1, U2.6 (-)
unnamed: R6.2, R8.1, U3.6 (-)
unnamed: R14.1, U8.13 (RSET)
PTT: C4.1, J1.17, J3.R, U1.20 (GP15)
Q_OUT+: R6.1, U3.1, U3.2 (-), U4.16 (QBBP)
Q_OUT-: R8.2, U3.7, U4.15 (QBBN)
RESET: J1.7, SW1.1, U1.30 (RUN)
ROT_A: C1.1, J1.14, U1.4 (GP2)
ROT_B: C2.1, J1.15, U1.5 (GP3)
ROT_SW: C3.1, J1.16, U1.9 (GP6)
TX_I: R3.1, U1.27 (GP21)
TX_Q: R4.1, U1.26 (GP20)
UART_RX: J2.14, U1.2 (GP1)
UART_TX: J2.13, U1.1 (GP0)

Board: 2 copper layers, 97.0 x 97.0 mm, 98 parts (0 on the bottom side), 63 nets.

## Commit log

2024-04-15 Create ...
